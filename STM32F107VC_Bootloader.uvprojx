# Keil uVision project STM32F107VC_Bootloader.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F107VC_Bootloader +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\scr;..\Libraries\CMSIS\Core\CM3;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\Core\CM3\stm32f10x;.\scr\Can;.\scr\Include;.\scr\CanIf;.\scr\Ccp;.\scr\CanTp;.\scr\Dcm;.\scr\SecMLib\SecM;.\scr\FlApp\Fl;.\scr\FlApp\Appl;.\scr\SecMLib\Cal;.\scr\Lcd;.\scr\GUI;.\scr\Delay;.\scr\Lib
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./scr/: main.c stm32f10x_it.c sysinit.c
    ./scr/Can/: can.c Can_Cfg.c
    ./scr/CanIf/: CanIf.c CanIf_Cfg.c
    ./scr/CanTp/: CanTp.c CanTp_Cfg.c
    ./scr/Dcm/: Dcm.c Dcm_Dsd.c Dcm_Dsl.c Dcm_Dsp.c Dcm_Cfg.c
    ./scr/SecMLib/SecM/: SecM.c
    ./scr/FlApp/Fl/: FL.c FL_Cfg.c
    ./scr/FlApp/Appl/: Appl.c
    ./scr/SecMLib/Cal/: Cal.c
    ./scr/Lcd/: stm3210x_9325_lcd.c touch_7846.c
    ./scr/GUI/: GUI_LCD.C
    ./scr/Delay/: delay.c
    ./scr/Lib/: libconv.c
  group CMSIS
    ../Libraries/CMSIS/Core/CM3/: system_stm32f10x.c core_cm3.c
    ../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_cl.s
  group Readme
    ./Readme/: Readme.txt
  group Stdperiph_lib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
